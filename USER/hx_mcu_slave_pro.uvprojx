# Keil uVision project hx_mcu_slave_pro.uvprojx, settings and files
target MCU_SlaveProject (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: m3_slave_fork_app_v101 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\FIFO;..\BSP\MODBUS;..\BSP\UART;..\BSP\CAN;..\BSP\IO;..\BSP\LOADING;..\BSP\TIME;..\MAGNET;..\PLC;..\RFID;..\MOTOR;..\Music;..\ANTICO;..\SYSTEM\IWDG;..\IIC;..\SYSTEM\IIC;..\ENCODER
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x3d000
  memory RVCT9: RAM 0x20000000 size 0xbff0
  memory RVCT10: RAM 0x2000bff0 size 0x10
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c public_def_type.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/FIFO/: FIFO.c
    ../SYSTEM/IWDG/: iwdg.c
    ../SYSTEM/IIC/: myiic.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_can.c stm32f10x_iwdg.c
  group BSP/底层
    ../BSP/LOADING/: bsp_loading_dependency.c
    ../BSP/CAN/: bsp_can_dependency.c
    ../BSP/IO/: bsp_gpio_dependency.c
    ../BSP/TIME/: bsp_time_dependency.c
    ../BSP/UART/: bsp_usart_dependency.c
    ../BSP/MODBUS/: bsp_modbusrtu.c
  group IIC/存储
    ../IIC/: myiic_upper.c myiic_m24c64_method.c
  group MAGNET/走形
    ../MAGNET/: magnet_sensor_upper.c magnet_mpls_sensor_method.c magnet_xs_sensor_method.c magnet_lg_sensor_method.c
  group PLC/主机交互
    ../PLC/: plc_hub_upper.c plc_hub_custom_method.c host_hub_cc_method.c
  group RFID/读头
    ../RFID/: rfid_upper.c rfid_xs_method.c rfid_bjf_method.c rfid_xmz_method.c rfid_ck_method.c rfid_lg_method.c
  group PLAYER/播放器
    ../Music/: music_method.c
  group MOTOR/驱动器
    ../MOTOR/: motor_upper.c motor_fork_method.c motor_lift_method.c
  group ANTICO/防撞
    ../ANTICO/: antico_upper.c antico_knd_method.c
  group ENCODER/编码器
    ../ENCODER/: encoder_upper.c encoder_tbf_method.c encoder_tf_method.c
  group README
    ../: README.TXT
software components: CMSIS:CORE 5.5.0
